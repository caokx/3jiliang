# IAR project IAR_Proj_RN8611_RN7306_IOTMeter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_IAR; __IAR
  ICCARM.CCDiagSuppress: Pa039,Pa089,Pa093,Pe188
  ICCARM.CCIncludePath2: ..\..\App; ..\..\Bsp; ..\..\Devices; ..\..\DlT698; ..\..\DlT698\DL698_AL\Include; ..\..\DlT698\Dl698_Class\Include; ..\..\DlT698\Dl698_Def\Include; ..\..\DlT698\Dl698_DL\Include; ..\..\DlT698\Dl698_User_Data_Interface\Include; Define; ..\..\App\IOTMeterThreePhs; ..\..\Bsp\IOTMeterThreePhs; ..\..\RN_Lib; ..\..\CoreSupport; ..\..\RN_Lib\IAR_Lib; ..\..\CoreSupport\RN8xxx; ..\..\RN_Debug; ..\..\RN_Debug\Rn_Assert; ..\..\RN_Debug\RTT; ..\..\RN_Debug\RTT\RTT
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_Proj_RN8611_RN7306_IOTMeter.hex
  ILINK.IlinkOutputFile: IAR_Proj_RN8611_RN7306_IOTMeter.out
  ILINK.IlinkIcfFile: Support\Icf\RN8611GW_V2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: app_rn7306.c Bkgrd.c Dl645_ICEsam.c Dl645B_Com.c Dl698_EsamOp.c Energy.c Event.c Freeze.c Globals.c main.c Memory.c output.c Scom.c Secret.c
    ../../App/IOTMeterThreePhs/: File.c Measure.c Power_Up_Down.c SysConst.c
  group Bsp
    ../../Bsp/: AT45DB642D.c BSP_Esam.c BSP_IIC.c BSP_MultiFunPort.c BSP_Relay.c BSP_Spi.c BSP_Tmp.c BSP_Uart.c Drive_AllINT.c Drive_Clock.c FIFO.c Fm24Cxx.c Key.c Misc.c MyMath.c xTarget.c
    ../../Bsp/IOTMeterThreePhs/: RN7306.c
  group CoreSupport
    ../../CoreSupport/: core_cm0.c
    ../../CoreSupport/RN8xxx/: system_RN8XXX_V2.c
  group Devices
    ../../Devices/: Rn8xxx_Common.c Rn8xxx_DSP.c Rn8xxx_GPIO.c Rn8xxx_IIC.c Rn8xxx_INTC.c Rn8xxx_ISO7816.c Rn8xxx_KBI.c Rn8xxx_Lcd.c Rn8xxx_LvdCmpSar.c Rn8xxx_M2M.c Rn8xxx_RTC.c Rn8xxx_Spi.c Rn8xxx_SysTickCortexM0.c Rn8xxx_TC.c Rn8xxx_Uart.c
  group DLT698
    ../../DlT698/DL698_AL/: Dl698_AL.c Dl698AL_Act.c Dl698AL_asn1.c Dl698AL_Conn.c Dl698AL_Get.c Dl698AL_process.c Dl698AL_Report.c Dl698AL_Set.c
    ../../DlT698/Dl698_Def/: Dl698_Crc.c Dl698_Globals.c Dl698_Memory.c
    ../../DlT698/Dl698_DL/: Dl698_DL.c Dl698_Scom.c
    ../../DlT698/Dl698_User_Data_Interface/: Dl698_ICData.c Dl698_UserData.c Dl698_UserData_Encode645to698.c Dl698_UserData_Oad2DI.c
  group RN_Debug
    ../../RN_Debug/Rn_Assert/: Rn_Assert.c
    ../../RN_Debug/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group RN_Lib
    ../../RN_Lib/: Harmonic.c
    ../../RN_Lib/IAR_Lib/: rn8xxx_v2_lib.a
    Startup/: startup_RN8xxx_v2.s
