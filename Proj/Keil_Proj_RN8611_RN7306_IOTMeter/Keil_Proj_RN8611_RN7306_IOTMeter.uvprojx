# Keil uVision project Keil_Proj_RN8611_RN7306_IOTMeter.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Keil_Proj_RN8611_RN7306_IOTMeter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=188
  c include: ..\..\App;..\..\Bsp;..\..\Devices;..\..\DlT698;..\..\DlT698\DL698_AL\Include;..\..\DlT698\Dl698_Class\Include;..\..\DlT698\Dl698_Def\Include;..\..\DlT698\Dl698_DL\Include;..\..\DlT698\Dl698_User_Data_Interface\Include;.\Define;..\..\RN_Lib;..\..\CoreSupport;..\..\RN_Lib\Keil_Lib;..\..\CoreSupport\RN8xxx;..\..\RN_Debug\RTT\RTT;..\..\RN_Debug\Rn_Assert;..\..\RN_Debug;..\..\App\IOTMeterThreePhs;..\..\Bsp\IOTMeterThreePhs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x17800
  group App
    ../../App/: Bkgrd.c Dl645_ICEsam.c Dl645B_Com.c Dl698_EsamOp.c Energy.c Event.c Freeze.c Globals.c main.c Memory.c output.c Scom.c Secret.c
    ../../App/IOTMeterThreePhs/: File.c Measure.c Power_Up_Down.c SysConst.c
  group Bsp
    ../../Bsp/: AT45DB642D.c BSP_Esam.c BSP_IIC.c BSP_MultiFunPort.c BSP_Relay.c Drive_Clock.c FIFO.c Fm24Cxx.c Key.c Misc.c MyMath.c xTarget.c Drive_AllINT.c BSP_Spi.c BSP_Uart.c BSP_Tmp.c
    ../../Bsp/IOTMeterThreePhs/: RN7306.c
  group CoreSupport
    ../../CoreSupport/: core_cm0.c
    ../../CoreSupport/RN8xxx/: system_RN8XXX_V2.c
    ./Startup/: startup_RN8XXX_V2.s
  group Devices
    ../../Devices/: Rn8xxx_Common.c Rn8xxx_DSP.c Rn8xxx_GPIO.c Rn8xxx_IIC.c Rn8xxx_INTC.c Rn8xxx_ISO7816.c Rn8xxx_KBI.c Rn8xxx_Lcd.c Rn8xxx_LvdCmpSar.c Rn8xxx_RTC.c Rn8xxx_Spi.c Rn8xxx_SysTickCortexM0.c Rn8xxx_TC.c Rn8xxx_Uart.c Rn8xxx_M2M.c
  group DLT698
    ../../DlT698/DL698_AL/: Dl698_AL.c Dl698AL_Act.c Dl698AL_asn1.c Dl698AL_Conn.c Dl698AL_Get.c Dl698AL_process.c Dl698AL_Report.c Dl698AL_Set.c
    ../../DlT698/Dl698_Def/: Dl698_Crc.c Dl698_Globals.c Dl698_Memory.c
    ../../DlT698/Dl698_DL/: Dl698_DL.c Dl698_Scom.c
    ../../DlT698/Dl698_User_Data_Interface/: Dl698_ICData.c Dl698_UserData.c Dl698_UserData_Encode645to698.c Dl698_UserData_Oad2DI.c
  group RN_Lib
    ../../RN_Lib/Keil_Lib/: rn8xxx_v2_lib.lib
    ../../RN_Lib/: Harmonic.c
  group RN_Debug
    ../../RN_Debug/Rn_Assert/: Rn_Assert.c
    ../../RN_Debug/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
